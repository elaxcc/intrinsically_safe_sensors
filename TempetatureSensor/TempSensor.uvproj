# Keil uVision project TempSensor.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: TempSensor
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS FATLPCMCI_MTH configUSE_MUTEXES YDEBUG
  c include: ..\TempetatureSensor_1var;.\include;.\YLibrary;.\common_nxp\inc;.\drivers_nxp;.\ffat_chan;.\drivers_mthomas
  asm include: ..\TempetatureSensor
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group main
    ./: LPC2400.s main.c
  group FreeRTOS
    ./: croutine.c list.c port.c queue.c tasks.c timers.c portASM.s heap_2.c
  group YLibrary
    ./YLibrary/: YDebug.c YOneWire.c SensorsList.c YDelay.c SDRAM.c LCD.c YFileFifo.c Log.c WD.c
  group FatFS
    ./ffat_chan/: ff.c cc932.c
    ./common_nxp/src/: irq.c target.c timer.c swi_handler.s
    ./drivers_nxp/: dma.c mci.c readfifo.s rtc.c
    ./: Retarget.c monitor.c
    ./drivers_mthomas/: gettime_lpcrtc.c comm.c diskio.c
